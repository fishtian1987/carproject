# Keil uVision project Robot.uvprojx, settings and files
target Robot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Robot +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\include;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FWLIB\CMSIS\Include;..\HARDWARE\include;..\COMMON\include;..\COMMUNICATE\include;..\CONFIG\interface;..\TASK\include;..\RMLIB;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\CONFIG\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/src/: led.c beep.c rtc.c lcd.c nvic.c exti.c spi.c w25qxx.c sdcard.c uart_arm.c uart_syslink.c usart_remote.c uart_debug.c pwm_motors.c system.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_spi.c
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group CONFIG
    ../CONFIG/src/: config_param.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group TASK
    ../TASK/src/: remote.c stabilizer.c io.c gps.c supervise.c compass.c
  group RMLIB
    ../RMLIB/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h RMLib.lib
  group TEXT
    ../TEXT/: fontupd.c text.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c combug.c
  group COMMUNICATE
    ../COMMUNICATE/src/: atkp.c maslink.c armlink.c
